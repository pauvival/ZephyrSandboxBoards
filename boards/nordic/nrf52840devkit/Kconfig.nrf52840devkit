## boards/nordic/nrf52840devkit/board.yml
```yaml
board:
  name: nrf52840devkit
  full_name: nrf52840devkit
  vendor: nordic
  socs:
    - name: nrf52840
```
